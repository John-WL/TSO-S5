# IAR project 247-637 S-0001 V7.ewp, settings and files
configuration 247-637 S-0001 V7 (ARM, debug)
  General.OGChipSelectEditMenu: STM32F407VG ST STM32F407VG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F407xx
  ICCARM.CCIncludePath2: ../Inc; ../Drivers/STM32F4xx_HAL_Driver/Inc; ../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy; ../Drivers/CMSIS/Device/ST/STM32F4xx/Include; ../Drivers/CMSIS/Include
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: 247-637 S-0001 V7.hex
  ILINK.IlinkOutputFile: 247-637 S-0001 V7.out
  ILINK.IlinkIcfFile: stm32f407xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32f407xx.s
  group Application/User
    ../Src/: main.c stm32f4xx_hal_msp.c stm32f4xx_it.c
  group Application/User/driver
    ../Src/: piloteTimer6Up.c piloteTimer6Up.h
  group Application/User/driver/communication
    ../Src/: driver_i2c.c driver_i2c.h piloteCAN1.c piloteCAN1.h
  group Application/User/driver/lightColumn
    ../Src/: driver_greenLight.c driver_greenLight.h driver_redLight.c driver_redLight.h driver_yellowLight.c driver_yellowLight.h
  group Application/User/driver/stepperMotor
    ../Src/: driver_stepperMotorA1.c driver_stepperMotorA1.h driver_stepperMotorA2.c driver_stepperMotorA2.h driver_stepperMotorB1.c driver_stepperMotorB1.h driver_stepperMotorB2.c driver_stepperMotorB2.h
  group Application/User/driver/triac
    ../Src/: driver_passingByZero.c driver_passingByZero.h driver_triac.c driver_triac.h
  group Application/User/interface
    ../Src/: interface_lightColumn.c interface_lightColumn.h interface_mcp3021.c interface_mcp3021.h interface_pcf8574A.c interface_pcf8574A.h interface_stepperMotor.c interface_stepperMotor.h interface_triac.c interface_triac.h
  group Application/User/service
    ../Src/: serviceBaseDeTemps.c serviceBaseDeTemps.h
  group Application/User/service/appInput
    ../Src/: service_applicationlnputHandler.c service_applicationlnputHandler.h
  group Application/User/service/appOutput
    ../Src/: service_applicationOutputHandler.c service_applicationOutputHandler.h
  group Application/User/service/communication
    ../Src/: service_can.h
  group Application/User/service/math
    ../Src/: service_bitOperation.c service_bitOperation.h
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_can.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_exti.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
